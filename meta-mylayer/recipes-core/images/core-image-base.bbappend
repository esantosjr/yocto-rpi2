# Include our application in the existing Raspberry Pi image.
IMAGE_INSTALL:append = " hello-pi"
